options:
  parameters:
    generate_options: no_gui
    id: transmit
    output_language: python
    run_options: run
    title: Transmit
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/singern/Desktop/jeep-hack/runtime/wave.bin
    repeat: 'False'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 434e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: 20e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
